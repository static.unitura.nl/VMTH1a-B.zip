Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\DennisHoogenboezem\HSR Groep BV\Unitura - Documenten (2)\R&D\Producttekeningen\2. HOUTBETON VOORZIENINGEN (wood concrete)\VLEERMUIS EXTERN (bat boxes external)\VMTH1a\VMTH1a brontekeningen\VMTH1a-B.IFC
Time: 2026-01-29T09:11:32+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
